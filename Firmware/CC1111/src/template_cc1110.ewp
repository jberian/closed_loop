# IAR project template_cc1110.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC1111F32 CC1111F32
  ICC8051.CCDefines: chip=1111
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: usb\class_cdc; usb\library; usb\others
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk51ew_cc1111F32_noPM23.xcl
  group Headers
    ./: bleComms.h constants.h controlLoop.h crc_4b6b.h dataProcessing.h freqManagement.h globals.h hal_cc8051.h hal_defs.h hal_types.h init.h interrupts.h ioCCxx10_bitdef.h medtronicRF.h pumpCommands.h timingController.h
    mDrip/Debug/Exe/: mDrip_v1.33_Alexia.hex mDrip_v1.33_Jesus.hex mDrip_v1.33_Simon_2541559.hex mDrip_v1.33_Simon_2681974.hex mDrip_v1.33_Susana.hex xDrip_v1.33.apk
  group Sources
    ./: bleComms.c controlLoop.c crc_4b6b.c dataProcessing.c freqManagement.c init.c interrupts.c mDrip.c medtronicRF.c pumpCommands.c smartRecovery.c timingController.c
